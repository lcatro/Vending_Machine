# Keil uVision project AT89C2051 Main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: AT89C2051 Main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c
